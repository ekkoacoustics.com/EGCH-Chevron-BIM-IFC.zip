Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Chevron\EGCH-2812-9-000-DG Chevron.IFC
Time: 2024-11-05T12:25:59+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 27.7925482669784145; Volume Measure: 0.0277925482669784; Area Measure: 7.0750325987705089

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 27.7925482669784145; Volume Measure: 0.0277925482669784; Area Measure: 7.0750325987705089

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 27.7925482669784145; Volume Measure: 0.0277925482669784; Area Measure: 7.0750325987705089

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGCH-2812-9-000-DG Chevron | PSet_Mass_Property - Mass Measure: 27.7925482669784145; Volume Measure: 0.0277925482669784; Area Measure: 7.0750325987705089
EGCH-2812-9-000-DG Chevron | SOLIDWORKS Custom Properties - Description: CHEVRON; PartNo: EGCH-2812-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
