Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Chevron\EGCH-2812-9-000-SG Chevron.IFC
Time: 2024-11-05T12:25:41+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 29.7885673460083069; Volume Measure: 0.0297885673460083; Area Measure: 6.9154446271794168

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 29.7885673460083069; Volume Measure: 0.0297885673460083; Area Measure: 6.9154446271794168

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 29.7885673460083069; Volume Measure: 0.0297885673460083; Area Measure: 6.9154446271794168

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGCH-2812-9-000-SG Chevron | PSet_Mass_Property - Mass Measure: 29.7885673460083069; Volume Measure: 0.0297885673460083; Area Measure: 6.9154446271794168
EGCH-2812-9-000-SG Chevron | SOLIDWORKS Custom Properties - Description: CHEVRON; PartNo: EGCH-2812-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
