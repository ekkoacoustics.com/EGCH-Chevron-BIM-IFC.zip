Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Chevron\EGCH-66-9-000-DG Chevron.IFC
Time: 2024-11-05T12:27:58+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 2.9650133296125278; Volume Measure: 0.0029650133296125; Area Measure: 0.7721530303803291

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 2.9650133296125278; Volume Measure: 0.0029650133296125; Area Measure: 0.7721530303803291

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 2.9650133296125278; Volume Measure: 0.0029650133296125; Area Measure: 0.7721530303803291

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGCH-66-9-000-DG Chevron | PSet_Mass_Property - Mass Measure: 2.9650133296125278; Volume Measure: 0.0029650133296125; Area Measure: 0.7721530303803291
EGCH-66-9-000-DG Chevron | SOLIDWORKS Custom Properties - Description: CHEVRON; PartNo: EGCH-66-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
