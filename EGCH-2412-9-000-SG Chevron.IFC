Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Chevron\EGCH-2412-9-000-SG Chevron.IFC
Time: 2024-11-05T12:26:44+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 25.5330577251511954; Volume Measure: 0.0255330577251512; Area Measure: 5.9305660418495645

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 25.5330577251511954; Volume Measure: 0.0255330577251512; Area Measure: 5.9305660418495645

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 25.5330577251511954; Volume Measure: 0.0255330577251512; Area Measure: 5.9305660418495645

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGCH-2412-9-000-SG Chevron | PSet_Mass_Property - Mass Measure: 25.5330577251511954; Volume Measure: 0.0255330577251512; Area Measure: 5.9305660418495645
EGCH-2412-9-000-SG Chevron | SOLIDWORKS Custom Properties - Description: CHEVRON; PartNo: EGCH-2412-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
